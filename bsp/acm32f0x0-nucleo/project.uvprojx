# Keil uVision project project.uvprojx, settings and files
target ACM32F0x0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ACM32F0x0 +hex
  AfterMake: fromelf.exe --bin --output rtthread.bin ./build/keil/Obj/acm32f030.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: libraries\HAL_Driver\Inc;libraries\Device;libraries\CMSIS;applications;.;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\extension;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m0;..\..\components\drivers\hwcrypto;.;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\include;drivers;..\..\components\finsh;.;..\..\include;..\..\components\libc\posix\io\poll;..\..\components\libc\posix\io\stdio;..\..\components\libc\posix\ipc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\drivers\linker_scripts\link.sct
  group ACM32_HAL
    libraries/HAL_Driver/Src/: HAL_IWDT.c HAL_UART.c HAL_RTC.c HAL_EXTI.c HAL_DMA.c HAL_TIMER.c HAL_ADC.c HAL_I2C.c HAL_CRC.c HAL_WDT.c HAL_SPI.c HAL_GPIO.c
    libraries/Device/: Startup_ACM32F0x0.s System_ACM32F0x0.c
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/hwcrypto/: hw_symmetric.c hwcrypto.c hw_rng.c hw_crc.c
    ../../components/drivers/hwtimer/: hwtimer.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/ipc/: ringblk_buf.c dataqueue.c waitqueue.c workqueue.c completion.c waitqueue.c workqueue.c completion.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_dev.c spi_core.c spi_core.c spi_dev.c
    ../../components/drivers/src/: waitqueue.c ringbuffer.c completion.c
    ../../components/drivers/pm/: lptimer.c pm.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/watchdog/: watchdog.c
  group Drivers
    drivers/: drv_rtc.c drv_adc.c drv_soft_i2c.c drv_crypto.c drv_adc.c drv_wdt.c drv_i2c.c drv_hwtimer.c drv_pm.c drv_wdt.c drv_spi.c drv_gpio.c drv_i2c.c drv_hwtimer.c drv_pm.c drv_wdt.c drv_spi.c drv_gpio.c drv_spi.c drv_gpio.c drv_uart.c drv_soft_i2c.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../src/: device.c idle.c mempool.c timer.c ipc.c thread.c scheduler.c mem.c clock.c mempool.c scheduler.c components.c device.c thread.c idle.c mem.c object.c kservice.c components.c
