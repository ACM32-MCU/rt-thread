# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__
  ICCARM.CCIncludePath2: libraries\HAL_Driver\Inc; ..\..\include; ..\..\libcpu\arm\cortex-m33; ..\..\components\libc\compilers\common\extension; ..\..\components\libc\compilers\common; ..\..\components\libc\posix\ipc; ..\..\components\finsh; drivers; .; libraries\Device; applications; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\io\stdio; libraries\CMSIS; ..\..\components\drivers\audio; ..\..\libcpu\arm\common; ..\..\components\drivers\spi; ..\..\components\drivers\include; ..\..\components\drivers\usb\usbdevice; ..\..\components\drivers\hwcrypto; ..\..\components\dfs\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rtthread-iar.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkAdditionalLibs: libraries\Device\libSystem_Accelerate.a; libraries\HAL_Driver\Src\libHAL_EFlash_EX.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: template.out
  group ACM32_HAL
    libraries/HAL_Driver/Src/: HAL_UART.c HAL_TIMER.c HAL_FSUSB.c HAL_CAN.c HAL_RTC.c HAL_EXTI.c HAL_DMA.c HAL_ADC.c HAL_I2C.c HAL_DAC.c HAL_CRC.c HAL_WDT.c HAL_SPI.c HAL_IWDT.c HAL_GPIO.c HAL_EFlash.c
    libraries/Device/: Startup_ACM32F4_iar.s System_ACM32F4.c
  group Applications
    applications/: can_sample.c crc_sample.c hrng_sample.c main.c spi_sample.c alarm_sample.c symmetric_sample.c hwtimer_sample.c hash_sample.c i2c_sample.c wdt_sample.c
  group Compiler
    ../../components/libc/compilers/common/: time.c stdlib.c
    ../../components/libc/compilers/dlib/: syscall_remove.c syscalls.c syscall_write.c environ.c syscall_lseek.c syscall_close.c syscall_mem.c syscall_read.c syscall_open.c
  group CPU
    ../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../libcpu/arm/cortex-m33/: trustzone.c cpuport.c context_iar.S syscall_iar.S
  group DeviceDrivers
    ../../components/drivers/audio/: audio.c audio_pipe.c
    ../../components/drivers/can/: can.c
    ../../components/drivers/hwcrypto/: hw_symmetric.c hwcrypto.c hw_rng.c hw_crc.c hw_hash.c
    ../../components/drivers/hwtimer/: hwtimer.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/ipc/: ringbuffer.c workqueue.c completion.c dataqueue.c pipe.c ringblk_buf.c waitqueue.c
    ../../components/drivers/misc/: dac.c adc.c rt_drv_pwm.c pin.c
    ../../components/drivers/rtc/: rtc.c alarm.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    drivers/: drv_hwtimer.c drv_adc.c drv_spi.c drv_pin_table.c drv_i2c.c drv_pwm.c drv_dac.c drv_crypto.c drv_uart.c drv_rtc.c drv_can.c drv_usbd.c drv_gpio.c drv_wdt.c board.c drv_i2s.c
  group Filesystem
    ../../components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../src/: clock.c ipc.c timer.c kservice.c mem.c irq.c components.c thread.c mempool.c object.c device.c scheduler.c idle.c
  group rt_usbd
    ../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../components/drivers/usb/usbdevice/class/: hid.c
