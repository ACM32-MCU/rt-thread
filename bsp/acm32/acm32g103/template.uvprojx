# Keil uVision project template.uvprojx, settings and files
target rt-thread (6140000::V6.14::ARMCLANG)
  device: ACM32G103RCT6 Aisinochip
  pack: Aisinochip.ACM32G1.1.0.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x50000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf.exe --bin --output ./build/rt-thread-keil.bin ./build/keil/Objects/rt-thread.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x10000
