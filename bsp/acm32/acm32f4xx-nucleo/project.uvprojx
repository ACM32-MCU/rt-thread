# Keil uVision project project.uvprojx, settings and files
target rt-thread (6140000::V6.14::ARMCLANG)
  device: ACM32F403RET7 Aisinochip
  pack: Aisinochip.ACM32F4.1.0.2
  cpu: IRAM(0x20000000,0x30000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf.exe --bin --output ./build/rt-thread-keil.bin ./build/keil/Objects/rt-thread.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: libraries\HAL_Driver\Inc;libraries\Device;libraries\CMSIS;applications;.;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\extension;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m33;..\..\components\drivers\audio;..\..\components\drivers\include;..\..\components\drivers\hwcrypto;.;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\spi\sfud\inc;drivers;..\..\components\fal\inc;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\dfs\filesystems\elmfat;..\..\components\finsh;.;..\..\include;..\..\components\libc\posix\io\poll;..\..\components\libc\posix\io\stdio;..\..\components\libc\posix\ipc;..\..\components\drivers\usb\usbdevice;..\..\components\utilities\ulog
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group ACM32_HAL
    libraries/HAL_Driver/Src/: HAL_UART.c HAL_TIMER.c HAL_FSUSB.c HAL_CAN.c HAL_RTC.c HAL_EXTI.c HAL_DMA.c HAL_ADC.c HAL_I2C.c HAL_DAC.c HAL_CRC.c HAL_WDT.c HAL_SPI.c HAL_IWDT.c HAL_GPIO.c HAL_EFlash.c HAL_EFlash_EX.lib HAL_HRNG_20210325.lib HAL_SHA1_20210325.lib HAL_SHA256_20210325.lib HAL_AES_20210325.lib
    libraries/Device/: Startup_ACM32F4.s System_ACM32F4.c System_Accelerate.lib
  group Applications
    applications/: spi_sample.c hash_sample.c can_sample.c vcom_sample.c crc_sample.c wdt_sample.c hwtimer_sample.c alarm_sample.c fs_gd25q16b.c hrng_sample.c i2c_sample.c main.c symmetric_sample.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../../components/libc/compilers/armlibc/: syscall_mem.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c div0.c
    ../../../libcpu/arm/common/: backtrace.c showmem.c
    ../../libcpu/arm/cortex-m33/: cpuport.c context_rvds.S
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c trustzone.c
  group DeviceDrivers
    ../../components/drivers/audio/: audio.c audio_pipe.c
    ../../components/drivers/can/: can.c
    ../../components/drivers/hwcrypto/: hw_symmetric.c hwcrypto.c hw_rng.c hw_crc.c hw_hash.c
    ../../components/drivers/hwtimer/: hwtimer.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/ipc/: dataqueue.c waitqueue.c ringblk_buf.c completion.c pipe.c ringblk_buf.c workqueue.c ringbuffer.c completion.c pipe.c workqueue.c dataqueue.c waitqueue.c ringbuffer.c ringblk_buf.c
    ../../components/drivers/misc/: dac.c adc.c rt_drv_pwm.c dac.c adc.c rt_drv_pwm.c pin.c
    ../../../components/drivers/ipc/: waitqueue.c pipe.c ringblk_buf.c
    ../../components/drivers/rtc/: rtc.c alarm.c rtc.c alarm.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../components/drivers/spi/: spi_flash_sfud.c spi_core.c spi_dev.c spi_core.c spi_dev.c
  group Drivers
    drivers/: drv_uart.c drv_hwtimer.c drv_can.c drv_usbd.c drv_crypto.c drv_dac.c board.c drv_adc.c drv_pwm.c drv_can.c drv_usbd.c drv_crypto.c
    ../../components/dfs/src/: dfs_fs.c dfs.c dfs_file.c
  group Fal
    ../../components/fal/src/: fal_rtt.c fal_flash.c fal_partition.c fal.c
    ../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../components/dfs/src/: dfs_posix.c
    drivers/: drv_usbd.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: ffunicode.c dfs_elm.c ff.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
    ../../components/finsh/: msh_file.c
  group Kernel
    ../../src/: idle.c mem.c clock.c irq.c components.c ipc.c scheduler.c irq.c timer.c thread.c components.c kservice.c ipc.c irq.c thread.c clock.c mempool.c kservice.c idle.c components.c scheduler.c device.c ipc.c thread.c irq.c
    ../../components/drivers/usb/usbdevice/core/: usbdevice_core.c
    ../../components/drivers/usb/usbdevice/class/: mstorage.c
    ../../../src/: mem.c scheduler.c irq.c device.c timer.c
  group rt_usbd
    ../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../components/drivers/usb/usbdevice/class/: mstorage.c cdc_vcom.c
    ../../../src/: idle.c thread.c
  group Utilities
    ../../components/utilities/ulog/: ulog.c
    ../../components/utilities/ulog/backend/: console_be.c
