# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__
  ICCARM.CCIncludePath2: ..\..\..\components\libc\compilers\common\extension\fcntl\octal; libraries\HAL_Driver\Inc; ..\..\..\components\libc\compilers\common\include; ..\..\..\components\libc\posix\ipc; applications; ..\..\..\components\drivers\include; ..\..\..\components\libc\posix\io\stdio; .; ..\..\..\libcpu\arm\cortex-m33; libraries\Device; ..\..\..\components\finsh; ..\..\..\components\libc\posix\io\poll; libraries\CMSIS; ..\..\..\libcpu\arm\common; ..\..\..\include; drivers; ..\..\..\components\libc\compilers\common\extension
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rtthread-iar.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkAdditionalLibs: libraries\Device\libSystem_Accelerate.a; libraries\HAL_Driver\Src\libHAL_EFlash_EX.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: template.out
  group ACM32_HAL
    libraries/HAL_Driver/Src/: HAL_UART.c HAL_TIMER.c HAL_FSUSB.c HAL_CAN.c HAL_RTC.c HAL_EXTI.c HAL_DMA.c HAL_ADC.c HAL_I2C.c HAL_DAC.c HAL_CRC.c HAL_WDT.c HAL_SPI.c HAL_IWDT.c HAL_GPIO.c HAL_EFlash.c
    libraries/Device/: Startup_ACM32F4_iar.s System_ACM32F4.c
  group Applications
    applications/: hrng_sample.c vcom_sample.c alarm_sample.c wdt_sample.c i2c_sample.c spi_sample.c hash_sample.c main.c fs_gd25q16b.c symmetric_sample.c hwtimer_sample.c can_sample.c crc_sample.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_iar.S cpuport.c syscall_iar.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: drv_flash.c drv_adc.c drv_uart.c drv_pwm.c drv_crypto.c drv_dac.c drv_spi.c drv_usbd.c drv_gpio.c drv_i2c.c board.c drv_rtc.c drv_hwtimer.c drv_can.c drv_pin_table.c drv_wdt.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
